# Keil uVision project temp_control_pid.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: temp_control_pid +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c STARTUP.A51 pid.c lanya.c ds18b20.c E2PROM.c font.c lcd.c sys.c
